options:
  parameters:
    generate_options: qt_gui
    id: temp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '000110101100111110001101011001111100011010110011111'
    bps: '1'
    threshold: '1'
  states: {}
- name: i
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/praveen/Desktop/temp.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/praveen/Desktop/synk.bin
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: switch
    packet_len: '10'
    type: byte
  states: {state: bypassed}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '11000011110000111111'
    tagname: '"switch"'
    threshold: '1'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass TagSwitch(gr.sync_block):\n    def __init__(self,tag_key=\"\",button=1):\n        gr.sync_block.__init__(self,\n                               name=\"TagSwitch\",\n                               in_sig=[np.int8],\n                               out_sig=[np.int8]*2)\n        self.tag_key = tag_key\n        self.current_output = 0\n        self.button=button\n\n    def work(self, input_items, output_items):\n        tags = self.get_tags_in_range(0, 0, len(input_items[0]))\n        for tag in tags:\n            if pmt.to_python(tag.key) == self.tag_key:\n                self.current_output = 1 if self.current_output == 0 else 0\n                print(self.current_output)\n        \n        out_data_1 = output_items[1]\n        out_data_0 = output_items[0]\n\n        in_data = input_items[0]\n\n        if(int(self.current_output)):in_data = input_items[0]*0\n        else: pass\n        \n\n        # Copy input to both outputs\n        out_data_0[:] = in_data*self.button\n        out_data_1[:] = in_data*self.button\n\n        return len(in_data)\n        "
    button: i
    tag_key: '''switch'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class bit_stream_generator(gr.sync_block):
          """
          Custom block to generate a bit stream.
          """
          def __init__(self, bit_pattern="101010", samples_per_bit=1,sample_rate=32000):
              """
              Initialize the block.
              :param bit_pattern: String of '1's and '0's representing the bit pattern.
              :param bit_rate: Number of bits per second.
              """
              self.bit_pattern = [int(b) for b in bit_pattern]
              #self.bit_rate = bit_rate
              self.sample_rate = int(sample_rate)  # Default sample rate in samples/sec.
              self.samples_per_bit = int(samples_per_bit)
              self.noofcycles=10
              self.currentcycle=0
              
              super().__init__(
                  name="bit_stream_generator",
                  in_sig=None,
                  out_sig=[np.int8]  # Output a stream of bits as 8-bit integers
              )

          def work(self, input_items, output_items):
              """
              Process block logic.
              """
              output = output_items[0]
              #if(self.currentcycle<self.noofcycles):
              num_bits = len(output) // self.samples_per_bit
              bit_sequence = np.tile(self.bit_pattern, num_bits // len(self.bit_pattern) + 1)#divition only put 
              output[::] = bit_sequence[::]
              return len(output)
    bit_pattern: '"10101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101010101011000011110000111111"'
    sample_rate: '100'
    samples_per_bit: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0_0, '0']
- [epy_block_0, '1', blocks_char_to_float_0, '0']
- [epy_block_1, '0', blocks_file_sink_1, '0']
- [epy_block_1, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
